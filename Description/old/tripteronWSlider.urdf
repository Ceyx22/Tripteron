Commit message: made urdf xacro files

File: Description/old/tripteronWSlider.urdf (robot description, URDF)
Before this commit: robot tripteronBody, 13 links, 12 joints
Joints:
- joint theta12: origin xyz=0 0 0.1524 rpy=0.7854 -1.5708 0  -> xyz=0 0 0.1524 rpy=1.0472 0 0 
